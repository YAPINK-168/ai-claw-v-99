# Keil uVision project claw_machine.uvprojx, settings and files
target claw_machine (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: claw_machine +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,HARDWARE_V2
  c include: ..\CORE;..\HARDWARE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\hc6800;..\HARDWARE\IIC;..\MALLOC;..\USER\CRC16;D:\Keil_v5\ARM\ARMCC\include;..\bsp;..\app;..\user_drivers;..\user_drivers\key_driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1b800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../app/: game_app.c key_app.c net_app.c crc.c serial_app.c led_app.c
  group bsp
    ../bsp/: bsp.c software_it.c
  group user_drivers
    ../user_drivers/: usart_driver.c
    ../user_drivers/key_driver/: key_driver.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group USER
    ../USER/: stm32f10x_it.c system_stm32f10x.c stm32_cpu.c md5.c irq.c basic.c rc04v.c rc04v.h lcd.c adc.c set.c setgame.h bsp_stm32_flash.c key.c irq_hv0.c irq_hv2.c
  group MAIN
    ../USER/: define.h mainfile.c
  group NET
    ../USER/: net.c netservice.c net_hv0.c net_hv2.c
